options:
  parameters:
    author: lab512
    generate_options: qt_gui
    id: forth
    output_language: python
    title: Tx RL Channel selector
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '2000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '3000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '4000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '5000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '6000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0_0_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '7000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0_0_0_0_0_0_0_0
  id: blocks_add_xx
  parameters:
    num_inputs: '7'
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: short
  states: {state: disabled}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.001'
    noise_voltage: '0.1'
    seed: '0'
    taps: 1.0 + 1.0j
  states: {}
- name: channels_channel_model_0_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.001'
    noise_voltage: '0.1'
    seed: '1'
    taps: 1.0 + 1.0j
  states: {}
- name: channels_channel_model_0_0_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.001'
    noise_voltage: '0.1'
    seed: '2'
    taps: 1.0 + 1.0j
  states: {}
- name: channels_channel_model_0_0_0_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.001'
    noise_voltage: '0.1'
    seed: '3'
    taps: 1.0 + 1.0j
  states: {}
- name: channels_channel_model_0_0_0_0_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.001'
    noise_voltage: '0.1'
    seed: '4'
    taps: 1.0 + 1.0j
  states: {}
- name: channels_channel_model_0_0_0_0_0_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.001'
    noise_voltage: '0.1'
    seed: '5'
    taps: 1.0 + 1.0j
  states: {}
- name: channels_channel_model_0_0_0_0_0_0_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.001'
    noise_voltage: '0.1'
    seed: '6'
    taps: 1.0 + 1.0j
  states: {}
- name: channels_channel_model_0_1
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.001'
    noise_voltage: '0.1'
    seed: '11'
    taps: 0.5 + 0.5j
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import os
      import copy
      import sys      
      import time
      import schedule
      import threading
      from datetime import datetime, timedelta
      from timeslot import Timeslot  
      import numpy as np
      import matplotlib.pyplot as plt
      import torch
      import tensorflow as tf
      from gnuradio import gr
      import pmt
      from tensorflow.keras import Model
      from tensorflow.keras.layers import Layer, Dense, Softmax
      from tensorflow.keras.layers import Dense

      from gym import Env

      # Number of messages - Dict from MAC
      #M = 8


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
      	"""Embedded Python Block example - a simple multiply const"""

      	def __init__(self,number_of_channels=7,seed = 0, num_GPU=0.0, active_threshold= 0.9, slot_time = 1, window_size = 5, gamma = 1, learning_rate = 0.01):  # only default arguments here
      		"""arguments to this function show up as parameters in GRC"""
      		gr.sync_block.__init__(
      			self,
      			name='RL Select channel',   # will show up in GRC
      			in_sig=[np.complex64,np.complex64,np.complex64,np.complex64,np.complex64,np.complex64,np.complex64],
      			out_sig=[np.int16]
      		)
      		

      		#initailize tensorflow and GPU usage
      		print('Tensorflow version: ', tf.__version__)

      		gpus = tf.config.experimental.list_physical_devices("GPU")
      		print('Number of GPUs available :', len(gpus))
      		
      		if num_GPU < len(gpus):
      		    tf.config.experimental.set_visible_devices(gpus[num_GPU], 'GPU')
      		    tf.config.experimental.set_memory_growth(gpus[num_GPU], True)
      		    print('Only GPU number', num_GPU, 'used')

      		#initialize Channel sensing
      		self.active_threshold = active_threshold
      		self.number_of_channels = number_of_channels
      		if (self.number_of_channels+1)%2!=0:
                  		print('/!\ Please enter an even number of channels')
      		self.channels = np.zeros(self.number_of_channels)
      		self.slot_time = slot_time
      		self.last_datetime = datetime.now()
      		self.window_size = window_size
      		self.grid = np.zeros((self.window_size, self.number_of_channels))

      		
      		#initialize DQN env
      		
      		#initialize DQN Neural Network
      		self.gamma = gamma
      		self.learning_rate = learning_rate
      		self.actions_number = self.number_of_channels
      		self.history_length = 1000 # Initialise history size
      		# The history is a list of lists. Each inner list will contain an experience
      		self.history = [[]for i in range(self.history_length)] 
      		# Keeps a history index : when we reach the end of the buffer, we satr to refill from the beginning (FIFO)
      		self.history_idx = 0 
      		
      		#Create and initialize the online DQN
      		self.DQN_online = tf.keras.models.Sequential([
                  	Dense(2*self.number_of_channels, activation='relu'),
                  	Dense(self.actions_number, activation='softplus') #Outputs positive values
      		])
      		self.DQN_online.build(input_shape=(None, self.number_of_channels*2)) #Build the model to create the weights
      		
      		#Create and initialize the offline DQN
      		self.DQN_offline = tf.keras.models.Sequential([
      		Dense(2*self.number_of_channels, activation='relu'),
      		Dense(self.actions_number, activation='softplus') #Outputs positive values
      		])
      		self.DQN_offline.build(input_shape=(None, self.number_of_channels*2)) #Build the model to create the weights
      		
      		self.copy_parameters() #Copy the weights of the online network to the offline network
      		
      		self.loss_func = tf.keras.losses.MSE
      		self.optimizer = tf.keras.optimizers.Adam(self.learning_rate)
      		
      		
      		#Get initial state
      		dq_env = DQEnv(random=False)
      		dq_env.initialize()
      		
      		print(dq_env.get_init_state())
      		
      		#agent_dq = DQAgent(nb_channels=7, learning_rate=0.01, gamma=1)
      		
      		self.init_DQN_flag = 0
      		self.seed = seed
      		self.init_state = [int((self.number_of_channels-1)/2), int(self.window_size-1)]
      		self.ch_state = self.init_state[1]
      		self.curr_ch = self.init_state[0]
      		self.sent_mess = 0
      		tf.random.set_seed(seed)
      		
      		# init channels states to 0
      		for i in range(0,self.number_of_channels): 
      			self.channels[i] = 0
      		
      		self.initialize_DQN()
      		
      		
      	#runtime code
      	def work(self, input_items, output_items):
      		"""example: multiply with constant"""
      		#sample channels
      		for i in range(0,np.size(input_items,0)):
      			
      			#check slot time
      			if datetime.now() - self.last_datetime > timedelta(days=0, seconds=self.slot_time, microseconds=0, milliseconds=0, minutes=0, hours=0, weeks=0):
      				self.grid = self.make_grid(self.grid,self.channels)
      				self.last_datetime = datetime.now()
      				self.channels = np.zeros(self.number_of_channels)
      				print(self.grid.T)
      			if (np.mean(input_items[i][:])>self.active_threshold):
      				self.channels[i] = 1
      			
      			#FIFO push channels experience to replay buffer	
      						
      			output_items[0][:] = input_items[i]
      		return len(output_items[0])

      	def copy_parameters(self):
      		"""Copy the parameters of the online network to the offline network"""

      		weights = self.DQN_online.get_weights()
      		self.DQN_offline.set_weights(weights)

      	def make_grid(self,grid,channels):
      		grid = np.append(grid, channels).reshape(self.window_size+1,7)
      		grid = np.delete(grid, 0, 0)
      		grid = grid.reshape(self.window_size,self.number_of_channels)
      		return grid.astype(np.float32)
              
      	def run(self, action):
      		self.sent_mess += 1
      		self.ch_state  = (self.ch_state + 1)%self.window_size
      		self.curr_ch = (self.curr_ch + action)%self.number_of_channels
      		reward = self.grid.T[self.curr_ch, self.ch_state]
      		if self.sent_mess != self.window_size: 
      		    end = 0
      		else :
      		    end = 1
      		return(reward, [self.grid.T[:, self.ch_state], self.one_hot(self.curr_ch, self.number_of_channels), end])
      		
      	def get_init_state(self):
      		return [self.grid.T[:, self.init_state[1]], self.one_hot(self.init_state[0], self.number_of_channels), 0]
      		
      	def initialize_DQN(self):
      		self.ch_state = self.init_state[1]
      		self.curr_ch = self.init_state[0]
      		self.sent_mess = 0
      		
      	def one_hot(self, index, depth):
      		oh = np.zeros(depth, dtype=np.float32)
      		oh[index] = 1
      		return oh
      		
      	def evaluate_dq_agent(agent, grid, display = False):

      	    action_history=[]
      	    tot_reward = 0
          
      	    dq_env.initialize()
      	    first_state = dq_env.get_init_state()
      	    action = agent.choose_action(first_state, epsilon = 0)
      	    action_history.append(action)
      	    reward, new_state = dq_env.run(action)
      	    tot_reward += reward
      	    
      	    for j in range(grid.T.shape[1]-1):
      	    	state = new_state
      	    	action = agent.choose_action(state, epsilon = 0)
      	    	action_history.append(action)
      	    	reward, new_state = dq_env.run(action)
      	    	tot_reward += reward

      	    choosen_channels = [(grid.shape[0]-1)/2]
      	    for idx in range(len(action_history)):
      	    	choosen_channels.append((choosen_channels[idx]+action_history[idx])%grid.shape[0])
      	    choosen_channels = choosen_channels[1:]
      	    return tot_reward

      	
      class Normalization(Layer):
      	def __init__(self, **kwargs):
      		super(Normalization, self).__init__(**kwargs)

      	def call(self, symbols):        
      		# Normalize power per symbol to 1
      		en_moy = tf.sqrt(2 * tf.reduce_mean(tf.square(symbols)))
      		symbols_norm = tf.divide(symbols, en_moy)
      		
      		return symbols_norm
      class R2C(Layer):

      	def __init__(self, **kwargs):
      		super(R2C, self).__init__(**kwargs)

      	def call(self, x):
      		# Converts 2Nc real numbers into Nc complex numbers
      		x_cplx = tf.complex(x[:, :1], x[:, 1:])            
      		return x_cplx

      class C2R(Layer):

      	def __init__(self, **kwargs):
      		super(C2R, self).__init__(**kwargs)

      	def call(self, y):
      		#converts Nc complex numbers into 2Nc real numbers
      		y_real = tf.concat([tf.math.real(y), tf.math.imag(y)], axis=1)
      		return y_real

      class OneHot(Layer):

      	def __init__(self, M, **kwargs):
      		super(OneHot, self).__init__(**kwargs)
      		self.M = M

      	def call(self, msg):

      		one_hot_msg = tf.one_hot(msg, depth = M)

      		return one_hot_msg

      class OneHot(Layer):

      	def __init__(self, M, **kwargs):
      		super(OneHot, self).__init__(**kwargs)
      		self.M = M

      	def call(self, msg):

      		one_hot_msg = tf.one_hot(msg, depth = M)

      		return one_hot_msg

      class Channel(Layer):

      	def __init__(self, **kwargs):
      		super(Channel, self).__init__(**kwargs)
                  
      	def call(self, x, snr):
      		# Adds random Gaussian noise to the input
      		noise_stddev = tf.sqrt( 2 / tf.pow(10., snr/10.0))
      		noise_r = tf.random.normal(shape = tf.shape(x), stddev = 1) * noise_stddev/tf.sqrt(2.)
      		noise_i = tf.random.normal(shape = tf.shape(x), stddev = 1) * noise_stddev/tf.sqrt(2.)
      		noise_cplx = tf.complex(noise_r, noise_i, name="noise")

      		y = x + noise_cplx

      		return y
      	
      	
      	
      	
      def generate_ds_msg(epoch_len, batch_size, M):

      	#Generate a dataset of 'epoch_len' batches of messages.
      	#Each batch have a size 'batch_size' and consists of messages (symbols) betwen 0 and M-1
      	rand_msg = tf.random.uniform(shape=[epoch_len, batch_size], minval=0, maxval=M, dtype=tf.int32)
      	features_ds = tf.data.Dataset.from_tensor_slices(rand_msg)

      	#The labels are the same as the features : 
      	#this is an autoencoder, we want to predict the same message that has been sent.
      	labels_ds = features_ds
      	return (features_ds, labels_ds)
      	
      class Autoencoder(Model):

      	def __init__(self, M, **kwargs):
      		super(Autoencoder, self).__init__(**kwargs)			
      		#Set the class' attributes
      		self.M = M

      		# Initialise the transmitter layers
      		self.oh = OneHot(self.M)
      		self.d1 = Dense(64, activation='elu')
      		self.d2 = Dense(2, activation=None)
      		self.norm = Normalization()
      		self.r2c = R2C()
      		
      		# Initialise the channel
      		self.ch = Channel()
      		
      		# Initialise the receiver layers
      		self.c2r = C2R()
      		self.d3 = Dense(64, activation='elu')
      		self.d4 = Dense(self.M, activation=None)
      		self.softm = Softmax()

      	def call(self, inputs, snr):
      			
      		# Transmitter
      		self.x1 = self.oh(inputs)
      		self.x2 = self.d1(self.x1)
      		self.x3 = self.d2(self.x2)
      		self.x4 = self.norm(self.x3)
      		self.x = self.r2c(self.x4)
      		    
      		#Channel
      		self.y = self.ch(self.x, snr)
      			
      			#Receiver
      		self.pb1 = self.c2r(self.y)
      		self.pb2 = self.d3(self.pb1)
      		self.pb3 = self.d4(self.pb2)
      		self.pb = self.softm(self.pb3)
      		    
      		return self.pb

      ###################
      # DO NOT LOOK AT THAT CODE

              
      def new_grid(random=False, nb_ch=7, nb_states=5, min_nb=1, max_nb=3, display=False):
          
          if random == False :
              grid = np.array([[1, 1, 1, 1, 0],
                               [0, 1, 0, 0, 0],
                               [0, 0, 0, 0, 0],
                               [0, 1, 0, 0, 0],
                               [1, 0, 0, 0, 0],
                               [0, 0, 0, 0, 0],
                               [0, 0, 0, 1, 1]])
          else:#sampled
              poss_ch = []
              print(gr.sync_block.input_items[2][0])
              nb_good_ch = np.random.randint(min_nb, max_nb)
              poss_ch.append(np.sort(np.random.choice(np.arange(nb_ch), size=(nb_good_ch), replace=False)))

              for i in range(nb_states-1):
                  new = 0
                  while new == 0:
                      nb_good_ch = np.random.randint(min_nb, max_nb)
                      new_ch = np.sort(np.random.choice(np.arange(nb_ch), size=(nb_good_ch), replace=False))
                      for i in range(len(poss_ch)):
                          if np.array_equal(poss_ch[i], new_ch):
                              new-=1
                      if new < 0:
                          new = 0
                      else:
                          new = 1

                  poss_ch.append(new_ch)

              grid = np.zeros((nb_ch, nb_states))

              for i in range(nb_states):
                  for j in range(poss_ch[i].shape[0]):
                      grid[poss_ch[i][j], i] = 1
                      
          if display == True:
              plt.figure()
              plt.imshow(np.flip(grid, axis=0), cmap='gray',  origin="lower", vmin=0, vmax=1)#, extent=[0, grid.shape[1], 0, grid.shape[0]])
              
          return grid.astype(np.float32)
          
      class DQEnv():
          def __init__(self, nb_channels = 7, nb_states=5, random=False):
              
              if (nb_channels+1)%2!=0:
                  print('/!\ Please enter an even number of channels')
                  
              self.nb_ch = nb_channels
              self.nb_states = nb_states
              
              self.grid = new_grid(random, self.nb_ch, self.nb_states, 1, int((self.nb_ch+1)/2), display=True)
              
              self.init_state = [int((self.nb_ch-1)/2), int(self.nb_states-1)]
              self.ch_state = self.init_state[1]
              self.curr_ch = self.init_state[0]
              self.sent_mess = 0
              
              print('This environment has ' + str(self.nb_ch) +' different channels')
              
          def run(self, action):
              
              self.sent_mess += 1
              
              self.ch_state  = (self.ch_state + 1)%self.nb_states
              
              self.curr_ch = (self.curr_ch + action)%self.nb_ch
              
              reward = self.grid[self.curr_ch, self.ch_state]
              
              if self.sent_mess != self.nb_states: 
                  end = 0
              else :
                  end = 1
              
              return(reward, [self.grid[:, self.ch_state], self.one_hot(self.curr_ch, self.nb_ch), end])
          
          def get_init_state(self):
              return [self.grid[:, self.init_state[1]], self.one_hot(self.init_state[0], self.nb_ch), 0]
          
          def initialize(self):
              self.ch_state = self.init_state[1]
              self.curr_ch = self.init_state[0]
              self.sent_mess = 0
              
          def one_hot(self, index, depth):
              oh = np.zeros(depth, dtype=np.float32)
              oh[index] = 1
              return oh
              
      def evaluate_dq_agent(agent, grid, display = False):

          action_history=[]
          tot_reward = 0
          
          dq_env.initialize()
          first_state = dq_env.get_init_state()
          action = agent.choose_action(first_state, epsilon = 0)
          action_history.append(action)
          reward, new_state = dq_env.run(action)
          tot_reward += reward
          
          for j in range(grid.shape[1]-1):
              state = new_state
              action = agent.choose_action(state, epsilon = 0)
              action_history.append(action)
              reward, new_state = dq_env.run(action)
              tot_reward += reward

          choosen_channels = [(grid.shape[0]-1)/2]
          for i in range(len(action_history)):
              choosen_channels.append((choosen_channels[i]+action_history[i])%grid.shape[0])
          choosen_channels = choosen_channels[1:]

          if display == True :
              plt.imshow(np.flip(grid, axis=0), origin="lower", cmap='gray', vmin=0, vmax=1)
              for i in range(len(choosen_channels)):
                  plt.scatter(i, grid.shape[0]-1-choosen_channels[i], color='r')
              print(str(int(tot_reward))+'/'+str(grid.shape[1])+' packets have been transmitted')
          return tot_reward        
    active_threshold: '0.3'
    gamma: '1'
    learning_rate: '0.01'
    num_GPU: '0.0'
    number_of_channels: '7'
    seed: '0'
    slot_time: '1'
    window_size: '5'
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """


      import numpy as np
      import time
      import schedule
      import threading
      from datetime import datetime, timedelta
      from timeslot import Timeslot
      from gnuradio import gr

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""
          def __init__(self, example_param=1.0, poisson_lambda=5.0, interval = 32000):  #change to numpy array size of inputs. only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Channels emulator',   # will show up in GRC
                  in_sig=[np.complex64,np.complex64,np.complex64,np.complex64,np.complex64,np.complex64,np.complex64],
                  out_sig=[np.complex64,np.complex64,np.complex64,np.complex64,np.complex64,np.complex64,np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param
              self.poisson_lambda = poisson_lambda
              stop_run_continuously = self.run_continuously() # enable therding for scheduler
              self.interval = interval
              self.active = [False,False,False,False,False,False,False]
              self.channels = [0,0,0,0,0,0,0]#cahnge to size of inputs
              for j in range(0,len(self.channels)): #cahnge to synchronus
              	self.channels[j] = datetime.now()
      	
          def work(self, input_items, output_items):
              """example: multiply with constant"""
              for i in range(0,np.size(input_items,0)):
              	if datetime.now() - self.channels[i] > (i+1)*timedelta(days=0, seconds=1, microseconds=0, milliseconds=0, minutes=0, hours=0, weeks=0):  #if time passed
              		#print(self.active)
              		if self.active[i] == True:
              			self.active[i] = False
              		else: 
      	        		self.active[i] = True
              		self.channels[i] = datetime.now() 
              	if self.active[i] == True:
              		self.turnon(i,input_items, output_items)
              	else:
              		self.turnoff(i,input_items, output_items)
              		
              			
              	
              return len(output_items[0])
      	
          def turnon(self,i, input_items, output_items):
          	output_items[i][:] = input_items[i] 
          	
          def turnoff(self,i, input_items, output_items):
          	output_items[i][:] = input_items[i] * 0
          	
          def run_continuously(interval=1):
          	cease_continuous_run = threading.Event()

          	class ScheduleThread(threading.Thread):
          	    def run(cls):
      	            while not cease_continuous_run.is_set():
                              schedule.run_pending()
                              time.sleep(interval)
          	continuous_thread = ScheduleThread()
          	continuous_thread.start()
          	return cease_continuous_run
    example_param: '1.0'
    interval: samp_rate
    poisson_lambda: '1.0'
  states: {state: disabled}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """


      import numpy as np
      import time
      import schedule
      import threading
      from datetime import datetime, timedelta
      from timeslot import Timeslot
      from gnuradio import gr

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""
          def __init__(self, example_param=1.0, poisson_lambda=5.0, interval = 32000):  #change to numpy array size of inputs. only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Channels emulator',   # will show up in GRC
                  in_sig=[np.complex64,np.complex64,np.complex64,np.complex64,np.complex64,np.complex64,np.complex64],
                  out_sig=[np.complex64,np.complex64,np.complex64,np.complex64,np.complex64,np.complex64,np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param
              self.poisson_lambda = poisson_lambda
              stop_run_continuously = self.run_continuously() # enable therding for scheduler
              self.interval = interval
              self.channels = [0,0,0,0,0,0,0]#cahnge to size of inputs
              for j in range(0,len(self.channels)): #cahnge to synchronus
              	self.channels[j] = datetime.now()
      	
          def work(self, input_items, output_items):
              """example: multiply with constant"""
              for i in range(0,np.size(input_items,0)):
              	active = np.random.poisson(self.poisson_lambda, 1) > 5.0
              	if datetime.now() - self.channels[i] > timedelta(days=0, seconds=1, microseconds=self.interval, milliseconds=0, minutes=0, hours=0, weeks=0):
              		self.turnoff(i,input_items, output_items)
              		if active == True:
              			self.channels[i] = datetime.now()
              	else:
              		self.turnon(i,input_items, output_items)
              return len(output_items[0])
      	
          def turnon(self,i, input_items, output_items):
          	output_items[i][:] = input_items[i] * self.example_param
          	
          def turnoff(self,i, input_items, output_items):
          	output_items[i][:] = input_items[i] * 0
          	
          def run_continuously(interval=1):
          	cease_continuous_run = threading.Event()

          	class ScheduleThread(threading.Thread):
          	    def run(cls):
      	            while not cease_continuous_run.is_set():
                              schedule.run_pending()
                              time.sleep(interval)
          	continuous_thread = ScheduleThread()
          	continuous_thread.start()
          	return cease_continuous_run
    example_param: '1.0'
    interval: samp_rate
    poisson_lambda: '1.0'
  states: {state: disabled}
- name: epy_block_1_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """


      import numpy as np
      import time
      import schedule
      import threading
      from datetime import datetime, timedelta
      from timeslot import Timeslot
      from gnuradio import gr

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""
          def __init__(self, example_param=1.0, poisson_lambda=5.0, interval = 32000):  #change to numpy array size of inputs. only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Channels emulator',   # will show up in GRC
                  in_sig=[np.complex64,np.complex64,np.complex64,np.complex64,np.complex64,np.complex64,np.complex64],
                  out_sig=[np.complex64,np.complex64,np.complex64,np.complex64,np.complex64,np.complex64,np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.mus = []
              self.example_param = example_param
              self.poisson_lambda = poisson_lambda
              stop_run_continuously = self.run_continuously() # enable therding for scheduler
              self.interval = interval
              self.active = [False,False,False,False,False,False,False]
              self.channels = [0,0,0,0,0,0,0]#cahnge to size of inputs
              for j in range(0,len(self.channels)): #cahnge to synchronus
              	self.channels[j] = datetime.now()
              	self.mus = np.append(self.mus, 1+int(np.random.exponential(scale = j)))
              print (self.mus)        	
              
          def work(self, input_items, output_items):
              """example: multiply with constant"""
              for i in range(0,np.size(input_items,0)):
              	
              	if datetime.now() - self.channels[i] > timedelta(days=0, seconds=self.mus[i], microseconds=0, milliseconds=0, minutes=0, hours=0, weeks=0):  #if time passed
              		#print(self.active)
              		if self.active[i] == True:
              			if 1 + np.random.exponential(scale = i) > i:
              				self.active[i] = False
              		else: 
      	        		self.active[i] = True
              		self.channels[i] = datetime.now() 
              	if self.active[i] == True:
              		self.turnon(i,input_items, output_items)
              	else:
              		self.turnoff(i,input_items, output_items)
              		
              			
              	
              return len(output_items[0])
      	
          def turnon(self,i, input_items, output_items):
          	output_items[i][:] = input_items[i] 
          	
          def turnoff(self,i, input_items, output_items):
          	output_items[i][:] = input_items[i] * 0
          	
          def run_continuously(interval=1):
          	cease_continuous_run = threading.Event()

          	class ScheduleThread(threading.Thread):
          	    def run(cls):
      	            while not cease_continuous_run.is_set():
                              schedule.run_pending()
                              time.sleep(interval)
          	continuous_thread = ScheduleThread()
          	continuous_thread.start()
          	return cease_continuous_run
    example_param: '1.0'
    interval: samp_rate
    poisson_lambda: '1.0'
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='MAC Controller',   # will show up in GRC
                  in_sig=[np.int16],
                  out_sig=[np.int16]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = input_items[0] * self.example_param
              return len(output_items[0])
    example_param: '1.0'
  states: {state: disabled}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import os
      import copy
      import sys      
      import time
      import schedule
      import threading
      from datetime import datetime, timedelta
      from timeslot import Timeslot  
      import numpy as np
      import matplotlib.pyplot as plt
      import torch
      import tensorflow as tf
      from gnuradio import gr
      import pmt
      from tensorflow.keras import Model
      from tensorflow.keras.layers import Layer, Dense, Softmax
      from tensorflow.keras.layers import Dense

      from gym import Env
      from gym.spaces import Discrete, Box

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self,number_of_channels=7,seed = 0, num_GPU=0.0, active_threshold= 0.9, slot_time = 1, window_size = 5, initial_channel = 0, gamma = 1, learning_rate = 0.01):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='RL Channels select mgoutay agent',   # will show up in GRC
                  in_sig=[np.complex64,np.complex64,np.complex64,np.complex64,np.complex64,np.complex64,np.complex64],
                  out_sig=[np.uint16]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              
              #initailize tensorflow and GPU usage
              print('Tensorflow version: ', tf.__version__)
              gpus = tf.config.experimental.list_physical_devices("GPU")
              print('Number of GPUs available :', len(gpus))
              
              if num_GPU < len(gpus):
              	tf.config.experimental.set_visible_devices(gpus[num_GPU], 'GPU')
              	tf.config.experimental.set_memory_growth(gpus[num_GPU], True)
              	print('Only GPU number', num_GPU, 'used')
              tf.random.set_seed(seed)
      	
              #initialize Channel sensing
              self.active_threshold = active_threshold
              self.number_of_channels = number_of_channels
              if (self.number_of_channels+1)%2!=0:
              	print('/!\ Please enter an even number of channels')
              self.channels = np.zeros(self.number_of_channels)
              self.slot_time = slot_time
              self.last_datetime = datetime.now()
              self.window_size = window_size
              self.grid = np.zeros((self.window_size, self.number_of_channels))
              self.initial_channel = initial_channel #change to random
              self.grid_flag = 0
              
              #initialize DQN env

              #initialize DQN Neural Network
              self.gamma = gamma
              self.learning_rate = learning_rate
              self.actions_number = self.number_of_channels
              self.epsilon = 0.75
              self.nb_trainings = 250
              self.loss = []  # Keep trak of the losses
              
              self.train_flag = False
              self.done = False
              #self.env = self.channelenv(self.number_of_channels, self.initial_channel , self.grid)
              
              
              self.dq_env = self.DQEnv(self.number_of_channels, self.window_size, False, self.grid.T)
              self.agent_dq = self.DQAgent(self.number_of_channels, self.learning_rate, self.gamma)
              
              print('##################################')
              print('ENV initial state:')
              print(self.dq_env.get_init_state())
              print('##################################')
            

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              #sample channels
              for i in range(0,np.size(input_items,0)):
              	#check slot time
              	if datetime.now() - self.last_datetime > timedelta(days=0, seconds=self.slot_time, microseconds=0, milliseconds=0, minutes=0, hours=0, weeks=0):
                          self.grid = self.make_grid(self.grid,self.channels)
                          self.last_datetime = datetime.now()
                          self.channels = np.zeros(self.number_of_channels)
                          #print(self.grid.T)
                          #self.env.transmit(self.grid.T)
                          self.grid_flag = self.grid_flag+1
                          if self.done == True:
                          	state = [self.channels.astype(np.float32), self.dq_env.one_hot(self.dq_env.init_state[0], self.number_of_channels), 0]
                          	output_items[0][:] = self.agent_dq.choose_action(state, self.epsilon)
              	if (np.mean(input_items[i][:])>self.active_threshold):
                          self.channels[i] = 1
              	
              
              if (self.grid_flag == self.number_of_channels*self.window_size+1):#and(datetime.now() - self.last_datetime > timedelta(days=0, seconds=self.slot_time, microseconds=0, milliseconds=0, minutes=0, hours=0, weeks=0)):
              	self.train_flag = True          	
              	print(self.grid.T)
      		# Run 200 episodes
              	for i in range(200):
                          self.dq_env.initialize()
                          state = self.dq_env.get_init_state()
      	    
                          action = self.agent_dq.choose_action(state, self.epsilon)
                          reward, new_state = self.dq_env.run(action)
      	    
                          self.agent_dq.insert_history(state, action, reward, new_state) # Insert state, action, reward, new state in history 
      	    
                          # While it's not the end of the episode
                          while new_state[2]==0 :
                          	state = new_state
      		
                          	action = self.agent_dq.choose_action(state, self.epsilon)
                          	reward, new_state = self.dq_env.run(action)
      		
                          	self.agent_dq.insert_history(state, action, reward, new_state) # Insert state, action, reward, new state in history
                          	
              	print('Replay buffer History populated')
              	                 	 

              	
              	

              if self.train_flag == True:
      	        print('Training...')
              	self.train_flag = False
              	for i in range(self.nb_trainings):
              		self.dq_env.initialize()
              		state = self.dq_env.get_init_state()
          
              		action = self.agent_dq.choose_action(state, self.epsilon)
              		reward, new_state = self.dq_env.run(action)
              		self.agent_dq.insert_history(state, action, reward, new_state) # Insert state, action, reward, new state in history 
              		self.agent_dq.learn(10) # Each time we store a new history, we perform a training on random data
          
              		# While it's not the end of the episode
              		while new_state[2]==0 :
              			state = new_state
              			action = self.agent_dq.choose_action(state, self.epsilon)
              			reward, new_state = self.dq_env.run(action)
              			self.agent_dq.insert_history(state, action, reward, new_state) # Insert state, action, reward, new state in history 
              			self.agent_dq.learn(10) # Each time we store a new history, we perform a training on random data
          
              		self.loss.append(tf.reduce_mean(self.agent_dq.loss).numpy()) #Save the losses for future visualization
              			#Every 10 iterations we copy the parameters of the online DQN to the offline DQN
              		if (i+1)%10 == 0:
              			self.agent_dq.copy_parameters()
              			print((i+1), end=', ')
              	self.done = True
            
              	
              return len(output_items[0])
              
          
          class DQEnv():
          	def __init__(self, nb_channels = 7, nb_states=5, random=False , grid = []):
              
      	    	if (nb_channels+1)%2!=0:
      	    		print('/!\ Please enter an even number of channels')
                  
      	    	self.nb_ch = nb_channels
      	    	self.nb_states = nb_states
              
      	    	self.grid = grid
              
      	    	self.init_state = [int((self.nb_ch-1)/2), int(self.nb_states-1)]
      	    	self.ch_state = self.init_state[1]
      	    	self.curr_ch = self.init_state[0]
      	    	self.sent_mess = 0
              
      	    	print('This environment has ' + str(self.nb_ch) +' different channels')
              
          	def run(self, action):
              
      	    	self.sent_mess += 1
              
      	    	self.ch_state  = (self.ch_state + 1)%self.nb_states
              
      	    	self.curr_ch = (self.curr_ch + action)%self.nb_ch
              
      	    	reward = self.grid[self.curr_ch, self.ch_state]
              
      	    	if self.sent_mess != self.nb_states: 
      	    		end = 0
      	    	else :
      	    		end = 1
              
      	    	return(reward, [self.grid[:, self.ch_state], self.one_hot(self.curr_ch, self.nb_ch), end])
          
          	def get_init_state(self):
      	    	return [self.grid[:, self.init_state[1]], self.one_hot(self.init_state[0], self.nb_ch), 0]
          
          	def initialize(self):
      	    	self.ch_state = self.init_state[1]
      	    	self.curr_ch = self.init_state[0]
      	    	self.sent_mess = 0
              
          	def one_hot(self, index, depth):
      	    	oh = np.zeros(depth, dtype=np.float32)
      	    	oh[index] = 1
      	    	return oh
          
          
          class DQAgent():
          	def __init__(self, nb_channels, learning_rate, gamma):
          		self.nb_ch = nb_channels
          		self.nb_actions = 3
          		self.gamma = gamma
          		self.learning_rate = learning_rate
          		
          		self.history_length = 1000
          		self.history = [[]for i in range(self.history_length)]
          		self.history_idx = 0
          		
          		#Create and initialize the online DQN
          		self.DQN_online = tf.keras.models.Sequential([Dense(2*self.nb_ch, activation='relu'), Dense(self.nb_actions, activation='softplus') #Outputs positive values 
          		])
          		self.DQN_online.build(input_shape=(None, self.nb_ch*2)) #Build the model to create the weights
          		
          		#Create and initialize the offline DQN
          		self.DQN_offline = tf.keras.models.Sequential([Dense(2*self.nb_ch, activation='relu'), Dense(self.nb_actions, activation='softplus') #Outputs positive values
          		])
          		self.DQN_offline.build(input_shape=(None, self.nb_ch*2)) #Build the model to create the weights
          		
          		self.copy_parameters() #Copy the weights of the online network to the offline network
          		
          		self.loss_func = tf.keras.losses.MSE
          		self.optimizer = tf.keras.optimizers.Adam(self.learning_rate)
              
              
          	def choose_action(self, state, epsilon):
          		"""Implements an epsilon-greedy policy"""
              
          		# Explore ?
          		if np.random.uniform(size=1) < epsilon :
          			action =  np.random.randint(low = -1, high = 2) # Take one action randomly {-1, 0, 1} with probability epsilon
              
          		#Choose the best action
          		else:    
          			sensed_ch, curr_ch, end = state #Decomposes the state
          			'''
          			* The shapes are :
          			- curr_ch : [self.nb_ch]
          			- sensed_ch : [self.nb_ch]
          			- end : one integer
          			'''
          			DQN_input = tf.concat([sensed_ch, curr_ch], axis=0)[tf.newaxis, :] #Create a state vector, which is the DQN input. Shape : [1, 2*self.nb_ch]
          			outputs = self.DQN_online(DQN_input).numpy() #Get the predicted Q values corresponding to the 3 actions
          			action = np.argmax(outputs)-1 #Take the action that has the highest predicted Q value (-1, 0, 1)
                  
          		return action
          
          	def learn(self, batch_size):
          		"""Sample experiences from the history and performs SGD"""
          		
          		# Samples random experiences from the history
          		idx = np.random.choice(range(self.history_length), batch_size, replace=False) # Create random indexes 
          		rdm_exp =  [self.history[i] for i in idx] # Take experiences corresponding to the random indexes
          		
          		# Each experience is written in this format : [state_vec, end, action, reward, n_state_vec, n_end] (see insert_history method)
          		
          		# Create 6 batches : states_vec, end_boolean, actions, rewards, new states_vec, new_end_boolean
          		states_vec = np.array([rdm_exp[i][0] for i in range(batch_size)]) # Shape : [Bs, 2*self.nb_ch]
          		end = np.array([rdm_exp[i][1] for i in range(batch_size)]) # Shape : [Bs]
          		actions = np.array([rdm_exp[i][2] for i in range(batch_size)]) # Shape : [BS]
          		rewards = np.array([rdm_exp[i][3] for i in range(batch_size)]) # Shape : [BS]
          		n_states_vec = np.array([rdm_exp[i][4] for i in range(batch_size)]) # Shape : [Bs, 2*self.nb_ch]
          		n_end = np.array([rdm_exp[i][5] for i in range(batch_size)]) # Shape : [BS]
          		
          		#Compute the best q_value for the new states
          		max_n_q_values = tf.reduce_max(self.DQN_offline(n_states_vec), axis=1).numpy()

          		with tf.GradientTape() as tape:
          			#Forward pass through the online network to predict the q_values
          			pred_q_values = self.DQN_online(states_vec)
          			
          			# Compute targets
          			targets = pred_q_values.numpy()
          			targets[np.arange(targets.shape[0]), actions+1]= rewards + (1-n_end) * self.gamma * max_n_q_values
          			
          			# Evaluate the loss
          			self.loss = self.loss_func(pred_q_values, targets)
              
          		# Compute gradients and perform the gradient descent
          		gradients = tape.gradient(self.loss, self.DQN_online.trainable_weights)
          		self.optimizer.apply_gradients(zip(gradients, self.DQN_online.trainable_weights))  
          
          	def insert_history(self, state, action, reward, n_state):
          		"""Insert experience in history"""
              
          		sensed_ch, curr_ch, end = state
          		state_vec = np.concatenate([sensed_ch, curr_ch], axis=0) # Create the state vector for the state
              
          		n_sensed_ch, n_curr_ch, n_end = n_state
          		n_state_vec = np.concatenate([n_sensed_ch, n_curr_ch], axis=0) # Create the state vector for the new state

          		self.history[self.history_idx] = [state_vec, end, action, reward, n_state_vec, n_end] # Insert everything in the history
              
          		self.history_idx = (self.history_idx+1)%self.history_length # Move the history_idx by one
          
          	def copy_parameters(self):
          		"""Copy the parameters of the online network to the offline network"""

          		weights = self.DQN_online.get_weights()
          		self.DQN_offline.set_weights(weights)



      	    	
          def build_model(states, actions):
          	model = Sequential()
          	model.add(Dense(24, activation='relu', input_shape=states))
          	model.add(Dense(actions, activation='linear'))
          	return model
      		

          def make_grid(self,grid,channels):
              grid = np.append(grid, channels).reshape(self.window_size+1,7)
              grid = np.delete(grid, 0, 0)
              grid = grid.reshape(self.window_size,self.number_of_channels)
              return grid.astype(np.float32)
    active_threshold: '0.3'
    gamma: '1'
    initial_channel: '0'
    learning_rate: '0.01'
    num_GPU: '1'
    number_of_channels: '7'
    seed: '1'
    slot_time: '1'
    window_size: '5'
  states: {state: disabled}
- name: epy_block_3_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import os
      import copy
      import sys      
      import time
      import schedule
      import threading
      from datetime import datetime, timedelta
      from timeslot import Timeslot  
      import numpy as np
      import matplotlib.pyplot as plt
      import torch
      import tensorflow as tf
      from gnuradio import gr
      import pmt
      from tensorflow.keras import Model
      from tensorflow.keras.layers import Layer, Dense, Softmax
      from tensorflow.keras.layers import Dense

      from gym import Env
      from gym.spaces import Discrete, Box


      from matplotlib.backends.backend_qt5agg import FigureCanvasQTAgg
      from matplotlib.figure import Figure
      from PyQt5 import QtCore #conda install pyqt
      from PyQt5 import QtWidgets
      HISTORY_BUFFER_LEN = 2000

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self,number_of_channels=7,seed = 0, num_GPU=0.0, active_threshold= 0.9, slot_time = 1, window_size = 5, initial_channel = 0, gamma = 1, learning_rate = 0.01, epsilon = 1):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='RL Channels select self agent',   # will show up in GRC
                  in_sig=[np.complex64,np.complex64,np.complex64,np.complex64,np.complex64,np.complex64,np.complex64],
                  out_sig=[np.uint16]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              
              #initailize tensorflow and GPU usage
              print('Tensorflow version: ', tf.__version__)
              gpus = tf.config.experimental.list_physical_devices("GPU")
              print('Number of GPUs available :', len(gpus))
              
              if num_GPU < len(gpus):
              	tf.config.experimental.set_visible_devices(gpus[num_GPU], 'GPU')
              	tf.config.experimental.set_memory_growth(gpus[num_GPU], True)
              	print('Only GPU number', num_GPU, 'used')
              tf.random.set_seed(seed)
      	
              #initialize Channel sensing
              self.active_threshold = active_threshold
              self.number_of_channels = number_of_channels
              if (self.number_of_channels+1)%2!=0:
              	print('/!\ Please enter an even number of channels')
              self.channels = np.zeros(self.number_of_channels)
              self.slot_time = slot_time
              self.last_datetime = datetime.now()
              self.window_size = window_size
              self.grid = np.zeros((self.window_size, self.number_of_channels))
              self.initial_channel = initial_channel #change to random
              self.grid_flag = 0
              self.channel_decision = self.initial_channel
              
              self.collision = 0
              self.total_error = 0 
              self.total_count = 1 
              #initialize DQN env
              #self.dq_env = self.DQEnv(self.number_of_channels, self.window_size, False, self.grid.T)

              #initialize DQN Neural Network
              self.gamma = gamma
              self.learning_rate = learning_rate
              self.actions_number = self.number_of_channels
              self.epsilon = epsilon
              self.nb_trainings = 300
              self.loss = []  # Keep trak of the losses
              self.channel_decision = self.initial_channel
              self.train_flag = False
              self.done = False
              
              self.agent_dq = self.DQAgent(self.number_of_channels, self.learning_rate, self.gamma)
              #sensed_ch, curr_ch, end = self.dq_env.get_init_state()
              #print('##################################')
              #print('ENV initial state:')
              #print('State: ', sensed_ch,', Current Channel: ', curr_ch)
              #print('##################################')
            

          def work(self, input_items, output_items):       	
              #Check slot time
              if (datetime.now() - self.last_datetime) > timedelta(days=0, seconds=self.slot_time, microseconds=0, milliseconds=0, minutes=0, hours=0, weeks=0):
                  #Sample and mark channels activity
                  for i in range(0,np.size(input_items,0)):
                  	#Energy detected during time slot, mark as occupied 
                  	if (np.mean(abs(input_items[i][:]))>self.active_threshold):
                  		self.channels[i] = 1
                  for j in range (np.size(self.channels)): self.channels[j] = np.abs(self.channels[j]-1)#flip ones and zeros
                  print(self.channels,'    ', datetime.now())   
                  #when training is done, make a decision
                  if self.done == True:
                  	state = [self.channels.astype(np.float32), self.dq_env.one_hot(self.channel_decision, self.number_of_channels), 0]
                  	self.channel_decision = self.agent_dq.choose_action(state, 0)# epsilon = 0 only expoiltation wehn not training
                  	self.total_count += 1
                  	self.total_ratio = (self.total_error)/self.total_count
                  	print('CH: ',self.channels)
                  	temp = np.zeros(np.size(self.channels))
                  	temp[self.channel_decision]=1
                  	print('DC: ',temp)
                  	print('count: ', self.total_count, ' Errors: ', self.total_error, ' ratio: ',self.total_ratio)
               	
                  	if self.channels[self.channel_decision] == 0:
                  		self.collision += 1             
                  self.grid = self.make_grid(self.grid,(self.channels))
                  self.last_datetime = datetime.now()
                  self.channels = np.zeros(self.number_of_channels)
                  #print(self.grid)
                  
                  self.grid_flag += 1
              output_items[0][:]= self.channel_decision      
              if self.collision == 1:
              	self.total_error += 1
              	self.collision = 0
              	#self.grid_flag = self.window_size+1
              	

              	
              #Full window sized grid
              if (self.grid_flag == self.window_size+1): 
      		
              	#initialize DQN env
              	self.dq_env = self.DQEnv(self.number_of_channels, self.window_size, self.initial_channel, self.grid.T)
      	
      		# Run 200 episodes
              	for i in range(HISTORY_BUFFER_LEN):
                          
                          self.dq_env.initialize()
                          
                          state = self.dq_env.get_init_state()
                          action = self.agent_dq.choose_action(state, self.epsilon)
                          reward, new_state = self.dq_env.run(action)
      	    
                          self.agent_dq.insert_history(state, action, reward, new_state) # Insert state, action, reward, new state in history 
      	    
                          # While it's not the end of the episode
                          while new_state[2]==0 :
                          	state = new_state
                          	action = self.agent_dq.choose_action(state, self.epsilon)
                          	reward, new_state = self.dq_env.run(action)
      		
                          	self.agent_dq.insert_history(state, action, reward, new_state) # Insert state, action, reward, new state in history
              	
              	self.train_flag = True                      	
              	print('Replay buffer History populated')
              	                 	 

              	
              	

              if self.train_flag == True:
      	        print('Training...')
              	self.train_flag = False
              	
              	for i in range(self.nb_trainings):
              		self.dq_env.initialize()
              		state = self.dq_env.get_init_state()
          
              		action = self.agent_dq.choose_action(state, self.epsilon)
              		reward, new_state = self.dq_env.run(action)
              		self.agent_dq.insert_history(state, action, reward, new_state) # Insert state, action, reward, new state in history 
              		self.agent_dq.learn(64) # Each time we store a new history, we perform a training on random data
          
              		# While it's not the end of the episode
              		while new_state[2]==0 :
              			state = new_state
              			action = self.agent_dq.choose_action(state, self.epsilon)
              			reward, new_state = self.dq_env.run(action)
              			self.agent_dq.insert_history(state, action, reward, new_state) # Insert state, action, reward, new state in history 
              			self.agent_dq.learn(64) # Each time we store a new history, we perform a training on random data
          
              		self.loss.append(tf.reduce_mean(self.agent_dq.loss).numpy()) #Save the losses for future visualization
              			#Every 10 iterations we copy the parameters of the online DQN to the offline DQN
              		if (i+1)%10 == 0:
              			self.agent_dq.copy_parameters()
              			print((i+1), end=', ')
              	self.done = True
              	#plt.semilogy(np.arange(len(self.loss)), self.loss)
              	#plt.show()
              	self.evaluate_dq_agent(self.agent_dq , self.dq_env.grid)
              return len(output_items[0])
              

          
          
          class DQEnv():
          	def __init__(self, nb_channels = 7, nb_states=5, initial_state = 0 , grid = []):
              
      	    	if (nb_channels+1)%2!=0:
      	    		print('/!\ Please enter an even number of channels')
                  
      	    	self.nb_ch = nb_channels
      	    	self.nb_states = nb_states
              
      	    	self.grid = grid
      	    	print ('env grid:')
      	    	print(self.grid)
      	    	self.init_state = [int(initial_state), int(self.nb_states-1)]
      	    	self.ch_state = self.init_state[1]
      	    	self.curr_ch = self.init_state[0]
      	    	self.sent_mess = 0
              
      	    	print('This environment has ' + str(self.nb_ch) +' different channels')
              
          	def run(self, action):
              
      	    	self.sent_mess += 1
              
      	    	self.ch_state  = (self.ch_state + 1)%self.nb_states
              
      	    	self.curr_ch = action
      	    	
      	    	reward = np.abs(self.grid[self.curr_ch, self.ch_state])
              
      	    	if self.sent_mess != self.nb_states: 
      	    		end = 0
      	    	else :
      	    		end = 1
              
      	    	return(reward, [self.grid[:, self.ch_state], self.one_hot(self.curr_ch, self.nb_ch), end])
          
          	def get_init_state(self):
      	    	return [self.grid[:, self.init_state[1]], self.one_hot(self.init_state[0], self.nb_ch), 0]
          
          	def initialize(self):
      	    	self.ch_state = self.init_state[1]
      	    	self.curr_ch = self.init_state[0]
      	    	self.sent_mess = 0
              
          	def one_hot(self, index, depth):
      	    	oh = np.zeros(depth, dtype=np.float32)
      	    	oh[index] = 1
      	    	return oh
          
          
          class DQAgent():
          	def __init__(self, nb_channels, learning_rate, gamma):
          		self.nb_ch = nb_channels
          		self.nb_actions = nb_channels
          		self.gamma = gamma
          		self.learning_rate = learning_rate
          		
          		self.history_length = HISTORY_BUFFER_LEN
          		self.history = [[]for i in range(self.history_length)]
          		self.history_idx = 0
          		
          		#Create and initialize the online DQN
          		self.DQN_online = tf.keras.models.Sequential([Dense(2*self.nb_ch, activation='relu'), Dense(self.nb_actions, activation='softplus') #Outputs positive values 
          		])
          		self.DQN_online.build(input_shape=(None, self.nb_ch*2)) #Build the model to create the weights
          		
          		#Create and initialize the offline DQN
          		self.DQN_offline = tf.keras.models.Sequential([Dense(2*self.nb_ch, activation='relu'), Dense(self.nb_actions, activation='softplus') #Outputs positive values
          		])
          		self.DQN_offline.build(input_shape=(None, self.nb_ch*2)) #Build the model to create the weights
          		
          		self.copy_parameters() #Copy the weights of the online network to the offline network
          		
          		self.loss_func = tf.keras.losses.MSE
          		self.optimizer = tf.keras.optimizers.Adam(self.learning_rate)
              
              
          	def choose_action(self, state, epsilon):
          		"""Implements an epsilon-greedy policy"""
          		sensed_ch, curr_ch, end = state
          		# Explore ?
          		if np.random.uniform(size=1) < epsilon :
          			action =  np.random.randint(low = 0, high = np.size(sensed_ch)) ####### Take one action randomly {0, 1, 2, 3, 4, 5, 6} with probability epsilon
          			
              
          		#Choose the best action
          		else:    
          			#sensed_ch, curr_ch, end = state #Decomposes the state
          			'''
          			* The shapes are :
          			- curr_ch : [self.nb_ch]
          			- sensed_ch : [self.nb_ch]
          			- end : one integer
          			'''
          			DQN_input = tf.concat([sensed_ch, curr_ch], axis=0)[tf.newaxis, :] #Create a state vector, which is the DQN input. Shape : [1, 2*self.nb_ch]
          			outputs = self.DQN_online(DQN_input).numpy() #Get the predicted Q values corresponding to the 3 actions
          			action = np.argmax(outputs)#-1 #Take the action that has the highest predicted Q value (0, 1, 2, 3, 4, 5, 6)			
          			#print(outputs)
          		return action
          
          	def learn(self, batch_size):
          		"""Sample experiences from the history and performs SGD"""
          		
          		# Samples random experiences from the history
          		idx = np.random.choice(range(self.history_length), batch_size, replace=False) # Create random indexes 
          		rdm_exp =  [self.history[i] for i in idx] # Take experiences corresponding to the random indexes
          		
          		# Each experience is written in this format : [state_vec, end, action, reward, n_state_vec, n_end] (see insert_history method)
          		
          		# Create 6 batches : states_vec, end_boolean, actions, rewards, new states_vec, new_end_boolean
          		states_vec = np.array([rdm_exp[i][0] for i in range(batch_size)]) # Shape : [Bs, 2*self.nb_ch]
          		end = np.array([rdm_exp[i][1] for i in range(batch_size)]) # Shape : [Bs]
          		actions = np.array([rdm_exp[i][2] for i in range(batch_size)]) # Shape : [BS]
          		rewards = np.array([rdm_exp[i][3] for i in range(batch_size)]) # Shape : [BS]
          		n_states_vec = np.array([rdm_exp[i][4] for i in range(batch_size)]) # Shape : [Bs, 2*self.nb_ch]
          		n_end = np.array([rdm_exp[i][5] for i in range(batch_size)]) # Shape : [BS]
          		
          		#Compute the best q_value for the new states
          		max_n_q_values = tf.reduce_max(self.DQN_offline(n_states_vec), axis=1).numpy()

          		with tf.GradientTape() as tape:
          			#Forward pass through the online network to predict the q_values
          			pred_q_values = self.DQN_online(states_vec)
          			
          			# Compute targets
          			targets = pred_q_values.numpy()
          			targets[np.arange(targets.shape[0]), actions]= rewards + (1-n_end) * self.gamma * max_n_q_values
          			
          			# Evaluate the loss
          			self.loss = self.loss_func(pred_q_values, targets)
              
          		# Compute gradients and perform the gradient descent
          		gradients = tape.gradient(self.loss, self.DQN_online.trainable_weights)
          		self.optimizer.apply_gradients(zip(gradients, self.DQN_online.trainable_weights))  
          
          	def insert_history(self, state, action, reward, n_state):
          		"""Insert experience in history"""
              
          		sensed_ch, curr_ch, end = state
          		state_vec = np.concatenate([sensed_ch, curr_ch], axis=0) # Create the state vector for the state
              
          		n_sensed_ch, n_curr_ch, n_end = n_state
          		n_state_vec = np.concatenate([n_sensed_ch, n_curr_ch], axis=0) # Create the state vector for the new state

          		self.history[self.history_idx] = [state_vec, end, action, reward, n_state_vec, n_end] # Insert everything in the history
              
          		self.history_idx = (self.history_idx+1)%self.history_length # Move the history_idx by one
          
          	def copy_parameters(self):
          		"""Copy the parameters of the online network to the offline network"""

          		weights = self.DQN_online.get_weights()
          		self.DQN_offline.set_weights(weights)

      		

          def make_grid(self,grid,channels):
              grid = np.append(grid, channels).reshape(self.window_size+1,7)
              grid = np.delete(grid, 0, 0)
              grid = grid.reshape(self.window_size,self.number_of_channels)
              return grid.astype(np.float32)
          
          def evaluate_dq_agent(self, agent, grid):

              action_history=[]
              tot_reward = 0
          
              self.dq_env.initialize()
              first_state = self.dq_env.get_init_state()
              action = agent.choose_action(first_state, epsilon = 0)
              action_history.append(action)
              reward, new_state = self.dq_env.run(action)
              tot_reward += reward
          
              for j in range(grid.shape[1]-1):
                  state = new_state
                  action = agent.choose_action(state, epsilon = 0)
                  action_history.append(action)
                  reward, new_state = self.dq_env.run(action)
                  tot_reward += reward
                  
              choosen_channels = [(grid.shape[0]-1)/2]
              for i in range(len(action_history)):
              	choosen_channels.append((choosen_channels[i]+action_history[i])%grid.shape[0])
              choosen_channels = choosen_channels[1:]
              plt.imshow(np.flip(grid, axis=0), origin="lower", cmap='gray', vmin=0, vmax=1)
              for i in range(len(choosen_channels)):
              	plt.scatter(i, grid.shape[0]-1-choosen_channels[i], color='r')
              plt.show()
              print(str(int(tot_reward))+'/'+str(grid.shape[1])+' packets have been transmitted')
              return tot_reward
    active_threshold: '0.9'
    epsilon: '0.25'
    gamma: '0.6'
    initial_channel: '0'
    learning_rate: '0.01'
    num_GPU: '1'
    number_of_channels: '7'
    seed: '1'
    slot_time: '1'
    window_size: '128'
  states: {}
- name: epy_block_4
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import time
      from datetime import datetime, timedelta

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Selected Channel',   # will show up in GRC
                  in_sig=[np.complex64,np.complex64,np.complex64,np.complex64,np.complex64,np.complex64,np.complex64,np.uint16],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param
              self.last_datetime = datetime.now()
              self.index = 0

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              if (datetime.now() - self.last_datetime) > timedelta(days=0, seconds=1, microseconds=0, milliseconds=0, minutes=0, hours=0, weeks=0):
                  #when training is done, make a decision  
                  self.last_datetime = datetime.now()
                  self.index = input_items[7][0]
                  #print(self.index)
                  if self.index < 0 or self.index > 6:
                  	self.index = 0

              output_items[0][:] = input_items[self.index][:]
              return len(output_items[0])
    example_param: '1.0'
  states: {}
- name: note_0
  id: note
  parameters:
    note: Deterministic channals
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: Probalistic channals
  states: {state: disabled}
- name: note_0_1
  id: note
  parameters:
    note: Exponential intervals
  states: {state: disabled}
- name: note_1
  id: note
  parameters:
    note: return feedback from Rx as reward
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    alpha8: '10.0'
    bw: samp_rate
    color8: '"dark blue"'
    fc: '0'
    fftsize: '1024'
    label1: CH1
    label2: CH2
    label3: CH3
    label4: CH4
    label5: CH5
    label6: CH6
    label7: CH7
    label8: '''CHOISE'''
    nconnections: '8'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '7'
    min: '0'
    type: short
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    alpha1: '0.5'
    alpha2: '0.5'
    bw: samp_rate
    color2: '6'
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    int_max: '1'
    int_min: '-200'
    nconnections: '2'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    timeout: '100'
  states: {state: disabled}
- name: zeromq_pull_msg_source_0
  id: zeromq_pull_msg_source
  parameters:
    timeout: '100'
  states: {state: disabled}

connections:
- [analog_sig_source_x_0, '0', epy_block_1, '0']
- [analog_sig_source_x_0, '0', epy_block_1_0, '0']
- [analog_sig_source_x_0, '0', epy_block_1_1, '0']
- [analog_sig_source_x_0, '0', epy_block_4, '0']
- [analog_sig_source_x_0_0, '0', epy_block_1, '1']
- [analog_sig_source_x_0_0, '0', epy_block_1_0, '1']
- [analog_sig_source_x_0_0, '0', epy_block_1_1, '1']
- [analog_sig_source_x_0_0, '0', epy_block_4, '1']
- [analog_sig_source_x_0_0_0, '0', epy_block_1, '2']
- [analog_sig_source_x_0_0_0, '0', epy_block_1_0, '2']
- [analog_sig_source_x_0_0_0, '0', epy_block_1_1, '2']
- [analog_sig_source_x_0_0_0, '0', epy_block_4, '2']
- [analog_sig_source_x_0_0_0_0, '0', epy_block_1, '3']
- [analog_sig_source_x_0_0_0_0, '0', epy_block_1_0, '3']
- [analog_sig_source_x_0_0_0_0, '0', epy_block_1_1, '3']
- [analog_sig_source_x_0_0_0_0, '0', epy_block_4, '3']
- [analog_sig_source_x_0_0_0_0_0, '0', epy_block_1, '4']
- [analog_sig_source_x_0_0_0_0_0, '0', epy_block_1_0, '4']
- [analog_sig_source_x_0_0_0_0_0, '0', epy_block_1_1, '4']
- [analog_sig_source_x_0_0_0_0_0, '0', epy_block_4, '4']
- [analog_sig_source_x_0_0_0_0_0_0, '0', epy_block_1, '5']
- [analog_sig_source_x_0_0_0_0_0_0, '0', epy_block_1_0, '5']
- [analog_sig_source_x_0_0_0_0_0_0, '0', epy_block_1_1, '5']
- [analog_sig_source_x_0_0_0_0_0_0, '0', epy_block_4, '5']
- [analog_sig_source_x_0_0_0_0_0_0_0, '0', epy_block_1, '6']
- [analog_sig_source_x_0_0_0_0_0_0_0, '0', epy_block_1_0, '6']
- [analog_sig_source_x_0_0_0_0_0_0_0, '0', epy_block_1_1, '6']
- [analog_sig_source_x_0_0_0_0_0_0_0, '0', epy_block_4, '6']
- [blocks_add_xx_0_0_0_0_0_0_0_0, '0', qtgui_waterfall_sink_x_0, '0']
- [channels_channel_model_0, '0', blocks_add_xx_0_0_0_0_0_0_0_0, '0']
- [channels_channel_model_0, '0', epy_block_0, '0']
- [channels_channel_model_0, '0', epy_block_3, '0']
- [channels_channel_model_0, '0', epy_block_3_0, '0']
- [channels_channel_model_0, '0', qtgui_freq_sink_x_0, '0']
- [channels_channel_model_0_0, '0', blocks_add_xx_0_0_0_0_0_0_0_0, '1']
- [channels_channel_model_0_0, '0', epy_block_0, '1']
- [channels_channel_model_0_0, '0', epy_block_3, '1']
- [channels_channel_model_0_0, '0', epy_block_3_0, '1']
- [channels_channel_model_0_0, '0', qtgui_freq_sink_x_0, '1']
- [channels_channel_model_0_0_0, '0', blocks_add_xx_0_0_0_0_0_0_0_0, '2']
- [channels_channel_model_0_0_0, '0', epy_block_0, '2']
- [channels_channel_model_0_0_0, '0', epy_block_3, '2']
- [channels_channel_model_0_0_0, '0', epy_block_3_0, '2']
- [channels_channel_model_0_0_0, '0', qtgui_freq_sink_x_0, '2']
- [channels_channel_model_0_0_0_0, '0', blocks_add_xx_0_0_0_0_0_0_0_0, '3']
- [channels_channel_model_0_0_0_0, '0', epy_block_0, '3']
- [channels_channel_model_0_0_0_0, '0', epy_block_3, '3']
- [channels_channel_model_0_0_0_0, '0', epy_block_3_0, '3']
- [channels_channel_model_0_0_0_0, '0', qtgui_freq_sink_x_0, '3']
- [channels_channel_model_0_0_0_0_0, '0', blocks_add_xx_0_0_0_0_0_0_0_0, '4']
- [channels_channel_model_0_0_0_0_0, '0', epy_block_0, '4']
- [channels_channel_model_0_0_0_0_0, '0', epy_block_3, '4']
- [channels_channel_model_0_0_0_0_0, '0', epy_block_3_0, '4']
- [channels_channel_model_0_0_0_0_0, '0', qtgui_freq_sink_x_0, '4']
- [channels_channel_model_0_0_0_0_0_0, '0', blocks_add_xx_0_0_0_0_0_0_0_0, '5']
- [channels_channel_model_0_0_0_0_0_0, '0', epy_block_0, '5']
- [channels_channel_model_0_0_0_0_0_0, '0', epy_block_3, '5']
- [channels_channel_model_0_0_0_0_0_0, '0', epy_block_3_0, '5']
- [channels_channel_model_0_0_0_0_0_0, '0', qtgui_freq_sink_x_0, '5']
- [channels_channel_model_0_0_0_0_0_0_0, '0', blocks_add_xx_0_0_0_0_0_0_0_0, '6']
- [channels_channel_model_0_0_0_0_0_0_0, '0', epy_block_0, '6']
- [channels_channel_model_0_0_0_0_0_0_0, '0', epy_block_3, '6']
- [channels_channel_model_0_0_0_0_0_0_0, '0', epy_block_3_0, '6']
- [channels_channel_model_0_0_0_0_0_0_0, '0', qtgui_freq_sink_x_0, '6']
- [channels_channel_model_0_1, '0', qtgui_freq_sink_x_0, '7']
- [channels_channel_model_0_1, '0', qtgui_waterfall_sink_x_0, '1']
- [epy_block_0, '0', epy_block_2, '0']
- [epy_block_0, '0', qtgui_number_sink_0, '0']
- [epy_block_1, '0', channels_channel_model_0, '0']
- [epy_block_1, '1', channels_channel_model_0_0, '0']
- [epy_block_1, '2', channels_channel_model_0_0_0, '0']
- [epy_block_1, '3', channels_channel_model_0_0_0_0, '0']
- [epy_block_1, '4', channels_channel_model_0_0_0_0_0, '0']
- [epy_block_1, '5', channels_channel_model_0_0_0_0_0_0, '0']
- [epy_block_1, '6', channels_channel_model_0_0_0_0_0_0_0, '0']
- [epy_block_1_0, '0', channels_channel_model_0, '0']
- [epy_block_1_0, '1', channels_channel_model_0_0, '0']
- [epy_block_1_0, '2', channels_channel_model_0_0_0, '0']
- [epy_block_1_0, '3', channels_channel_model_0_0_0_0, '0']
- [epy_block_1_0, '4', channels_channel_model_0_0_0_0_0, '0']
- [epy_block_1_0, '5', channels_channel_model_0_0_0_0_0_0, '0']
- [epy_block_1_0, '6', channels_channel_model_0_0_0_0_0_0_0, '0']
- [epy_block_1_1, '0', channels_channel_model_0, '0']
- [epy_block_1_1, '1', channels_channel_model_0_0, '0']
- [epy_block_1_1, '2', channels_channel_model_0_0_0, '0']
- [epy_block_1_1, '3', channels_channel_model_0_0_0_0, '0']
- [epy_block_1_1, '4', channels_channel_model_0_0_0_0_0, '0']
- [epy_block_1_1, '5', channels_channel_model_0_0_0_0_0_0, '0']
- [epy_block_1_1, '6', channels_channel_model_0_0_0_0_0_0_0, '0']
- [epy_block_2, '0', blocks_null_sink_0, '0']
- [epy_block_3, '0', qtgui_number_sink_0, '0']
- [epy_block_3_0, '0', epy_block_4, '7']
- [epy_block_3_0, '0', qtgui_number_sink_0, '0']
- [epy_block_4, '0', channels_channel_model_0_1, '0']
- [zeromq_pull_msg_source_0, out, zeromq_pub_msg_sink_0, in]

metadata:
  file_format: 1
