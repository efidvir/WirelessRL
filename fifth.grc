options:
  parameters:
    author: lab512
    generate_options: qt_gui
    id: fifth
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: e
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    rangeType: int
    start: '1'
    step: '1'
    stop: '100'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: e
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: analog_fastnoise_source_x_0_0_0
  id: analog_fastnoise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: analog_fastnoise_source_x_0_0_0_0
  id: analog_fastnoise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: analog_fastnoise_source_x_0_0_0_0_0_0
  id: analog_fastnoise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: analog_fastnoise_source_x_0_0_0_0_0_0_0
  id: analog_fastnoise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import os
      import copy
      import sys        
      import numpy as np
      import matplotlib.pyplot as plt
      import torch
      import tensorflow as tf
      from gnuradio import gr
      import pmt
      from tensorflow.keras import Model
      from tensorflow.keras.layers import Layer, Dense, Softmax
      from tensorflow.keras.layers import Dense

      # Number of messages - Dict from MAC
      #M = 8
      SEED = 1

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
      	"""Embedded Python Block example - a simple multiply const"""

      	def __init__(self, example_param=1.0, num_GPU=0.0, active_threshold= 10):  # only default arguments here
      		"""arguments to this function show up as parameters in GRC"""
      		gr.sync_block.__init__(
      			self,
      			name='Embedded Python Block',   # will show up in GRC
      			in_sig=[np.complex64,np.complex64,np.complex64,np.complex64,np.complex64,np.complex64,np.complex64],
      			out_sig=[np.complex64]
      		)
      		print('Tensorflow version: ', tf.__version__)

      		gpus = tf.config.experimental.list_physical_devices("GPU")
      		print('Number of GPUs available :', len(gpus))
      		
      		if num_GPU < len(gpus):
      		    tf.config.experimental.set_visible_devices(gpus[num_GPU], 'GPU')
      		    tf.config.experimental.set_memory_growth(gpus[num_GPU], True)
      		    print('Only GPU number', num_GPU, 'used')

      		dq_env = DQEnv(random=False)
      		self.active_threshold = active_threshold
      		
      		#Get initial state
      		dq_env.initialize()
      		print(dq_env.get_init_state())
      		tf.random.set_seed(SEED)
      		#agent_dq = DQAgent(nb_channels=7, learning_rate=0.01, gamma=1)
      		
      	def work(self, input_items, output_items):
      		"""example: multiply with constant"""
      		#sample channels
      		if (np.mean(input_items[0][:])>self.active_threshold):
      			print("active")
      		output_items[0][:] = input_items[0] 
      		return len(output_items[0])

      class Normalization(Layer):
      	def __init__(self, **kwargs):
      		super(Normalization, self).__init__(**kwargs)

      	def call(self, symbols):        
      		# Normalize power per symbol to 1
      		en_moy = tf.sqrt(2 * tf.reduce_mean(tf.square(symbols)))
      		symbols_norm = tf.divide(symbols, en_moy)
      		
      		return symbols_norm
      class R2C(Layer):

      	def __init__(self, **kwargs):
      		super(R2C, self).__init__(**kwargs)

      	def call(self, x):
      		# Converts 2Nc real numbers into Nc complex numbers
      		x_cplx = tf.complex(x[:, :1], x[:, 1:])            
      		return x_cplx

      class C2R(Layer):

      	def __init__(self, **kwargs):
      		super(C2R, self).__init__(**kwargs)

      	def call(self, y):
      		#converts Nc complex numbers into 2Nc real numbers
      		y_real = tf.concat([tf.math.real(y), tf.math.imag(y)], axis=1)
      		return y_real

      class OneHot(Layer):

      	def __init__(self, M, **kwargs):
      		super(OneHot, self).__init__(**kwargs)
      		self.M = M

      	def call(self, msg):

      		one_hot_msg = tf.one_hot(msg, depth = M)

      		return one_hot_msg

      class OneHot(Layer):

      	def __init__(self, M, **kwargs):
      		super(OneHot, self).__init__(**kwargs)
      		self.M = M

      	def call(self, msg):

      		one_hot_msg = tf.one_hot(msg, depth = M)

      		return one_hot_msg

      class Channel(Layer):

      	def __init__(self, **kwargs):
      		super(Channel, self).__init__(**kwargs)
                  
      	def call(self, x, snr):
      		# Adds random Gaussian noise to the input
      		noise_stddev = tf.sqrt( 2 / tf.pow(10., snr/10.0))
      		noise_r = tf.random.normal(shape = tf.shape(x), stddev = 1) * noise_stddev/tf.sqrt(2.)
      		noise_i = tf.random.normal(shape = tf.shape(x), stddev = 1) * noise_stddev/tf.sqrt(2.)
      		noise_cplx = tf.complex(noise_r, noise_i, name="noise")

      		y = x + noise_cplx

      		return y
      	
      	
      	
      	
      def generate_ds_msg(epoch_len, batch_size, M):

      	#Generate a dataset of 'epoch_len' batches of messages.
      	#Each batch have a size 'batch_size' and consists of messages (symbols) betwen 0 and M-1
      	rand_msg = tf.random.uniform(shape=[epoch_len, batch_size], minval=0, maxval=M, dtype=tf.int32)
      	features_ds = tf.data.Dataset.from_tensor_slices(rand_msg)

      	#The labels are the same as the features : 
      	#this is an autoencoder, we want to predict the same message that has been sent.
      	labels_ds = features_ds
      	return (features_ds, labels_ds)
      	
      class Autoencoder(Model):

      	def __init__(self, M, **kwargs):
      		super(Autoencoder, self).__init__(**kwargs)			
      		#Set the class' attributes
      		self.M = M

      		# Initialise the transmitter layers
      		self.oh = OneHot(self.M)
      		self.d1 = Dense(64, activation='elu')
      		self.d2 = Dense(2, activation=None)
      		self.norm = Normalization()
      		self.r2c = R2C()
      		
      		# Initialise the channel
      		self.ch = Channel()
      		
      		# Initialise the receiver layers
      		self.c2r = C2R()
      		self.d3 = Dense(64, activation='elu')
      		self.d4 = Dense(self.M, activation=None)
      		self.softm = Softmax()

      	def call(self, inputs, snr):
      			
      		# Transmitter
      		self.x1 = self.oh(inputs)
      		self.x2 = self.d1(self.x1)
      		self.x3 = self.d2(self.x2)
      		self.x4 = self.norm(self.x3)
      		self.x = self.r2c(self.x4)
      		    
      		#Channel
      		self.y = self.ch(self.x, snr)
      			
      			#Receiver
      		self.pb1 = self.c2r(self.y)
      		self.pb2 = self.d3(self.pb1)
      		self.pb3 = self.d4(self.pb2)
      		self.pb = self.softm(self.pb3)
      		    
      		return self.pb

      ###################

      def new_grid(random=False, nb_ch=7, nb_states=5, min_nb=1, max_nb=3, display=False):
          
          if random == False :
              grid = np.array([[1, 1, 1, 1, 0],
                               [0, 1, 0, 0, 0],
                               [0, 0, 0, 0, 0],
                               [0, 1, 0, 0, 0],
                               [1, 0, 0, 0, 0],
                               [0, 0, 0, 0, 0],
                               [0, 0, 0, 1, 1]])
          else:#sampled
              poss_ch = []
              print(gr.sync_block.input_items[2][0])
              nb_good_ch = np.random.randint(min_nb, max_nb)
              poss_ch.append(np.sort(np.random.choice(np.arange(nb_ch), size=(nb_good_ch), replace=False)))

              for i in range(nb_states-1):
                  new = 0
                  while new == 0:
                      nb_good_ch = np.random.randint(min_nb, max_nb)
                      new_ch = np.sort(np.random.choice(np.arange(nb_ch), size=(nb_good_ch), replace=False))
                      for i in range(len(poss_ch)):
                          if np.array_equal(poss_ch[i], new_ch):
                              new-=1
                      if new < 0:
                          new = 0
                      else:
                          new = 1

                  poss_ch.append(new_ch)

              grid = np.zeros((nb_ch, nb_states))

              for i in range(nb_states):
                  for j in range(poss_ch[i].shape[0]):
                      grid[poss_ch[i][j], i] = 1
                      
          if display == True:
              plt.figure()
              plt.imshow(np.flip(grid, axis=0), cmap='gray',  origin="lower", vmin=0, vmax=1)#, extent=[0, grid.shape[1], 0, grid.shape[0]])
              
          return grid.astype(np.float32)
          
      class DQEnv():
          def __init__(self, nb_channels = 7, nb_states=5, random=False):
              
              if (nb_channels+1)%2!=0:
                  print('/!\ Please enter an even number of channels')
                  
              self.nb_ch = nb_channels
              self.nb_states = nb_states
              
              self.grid = new_grid(random, self.nb_ch, self.nb_states, 1, int((self.nb_ch+1)/2), display=True)
              
              self.init_state = [int((self.nb_ch-1)/2), int(self.nb_states-1)]
              self.ch_state = self.init_state[1]
              self.curr_ch = self.init_state[0]
              self.sent_mess = 0
              
              print('This environment has ' + str(self.nb_ch) +' different channels')
              
          def run(self, action):
              
              self.sent_mess += 1
              
              self.ch_state  = (self.ch_state + 1)%self.nb_states
              
              self.curr_ch = (self.curr_ch + action)%self.nb_ch
              
              reward = self.grid[self.curr_ch, self.ch_state]
              
              if self.sent_mess != self.nb_states: 
                  end = 0
              else :
                  end = 1
              
              return(reward, [self.grid[:, self.ch_state], self.one_hot(self.curr_ch, self.nb_ch), end])
          
          def get_init_state(self):
              return [self.grid[:, self.init_state[1]], self.one_hot(self.init_state[0], self.nb_ch), 0]
          
          def initialize(self):
              self.ch_state = self.init_state[1]
              self.curr_ch = self.init_state[0]
              self.sent_mess = 0
              
          def one_hot(self, index, depth):
              oh = np.zeros(depth, dtype=np.float32)
              oh[index] = 1
              return oh
              
      def evaluate_dq_agent(agent, grid, display = False):

          action_history=[]
          tot_reward = 0
          
          dq_env.initialize()
          first_state = dq_env.get_init_state()
          action = agent.choose_action(first_state, epsilon = 0)
          action_history.append(action)
          reward, new_state = dq_env.run(action)
          tot_reward += reward
          
          for j in range(grid.shape[1]-1):
              state = new_state
              action = agent.choose_action(state, epsilon = 0)
              action_history.append(action)
              reward, new_state = dq_env.run(action)
              tot_reward += reward

          choosen_channels = [(grid.shape[0]-1)/2]
          for i in range(len(action_history)):
              choosen_channels.append((choosen_channels[i]+action_history[i])%grid.shape[0])
          choosen_channels = choosen_channels[1:]

          if display == True :
              plt.imshow(np.flip(grid, axis=0), origin="lower", cmap='gray', vmin=0, vmax=1)
              for i in range(len(choosen_channels)):
                  plt.scatter(i, grid.shape[0]-1-choosen_channels[i], color='r')
              print(str(int(tot_reward))+'/'+str(grid.shape[1])+' packets have been transmitted')
          return tot_reward        
    active_threshold: '10'
    example_param: '1.0'
    num_GPU: '0.0'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [analog_fastnoise_source_x_0, '0', epy_block_0, '0']
- [analog_fastnoise_source_x_0_0_0, '0', epy_block_0, '5']
- [analog_fastnoise_source_x_0_0_0_0, '0', epy_block_0, '4']
- [analog_fastnoise_source_x_0_0_0_0_0_0, '0', epy_block_0, '3']
- [analog_fastnoise_source_x_0_0_0_0_0_0_0, '0', epy_block_0, '6']
- [analog_sig_source_x_0, '0', epy_block_0, '1']
- [analog_sig_source_x_0_1, '0', epy_block_0, '2']
- [epy_block_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
